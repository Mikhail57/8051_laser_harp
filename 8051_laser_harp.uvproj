# Keil uVision project 8051_laser_harp.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: 8051_laser_harp-compile +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c timers.h timers.c
